# Keil uVision project helloworld.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: helloworld
  AfterMake: fromelf -c -v -a --output=@P.asm Objects\%L
  AfterMake: fromelf --bin --output=@P.bin Objects\%L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\ELF2_BSP;..\..\..\ELF2_BSP\CMSIS\Core\Include;..\..\..\ELF2_BSP\Debug;..\..\..\ELF2_BSP\Debug\RTT;..\..\..\ELF2_BSP\Device\ELF2\Include;..\..\..\ELF2_BSP\Device\ELF2\Source;..\..\..\ELF2_BSP\Device\ELF2\Source\ARM;..\..\..\ELF2_BSP\Driver;..\..\..\ELF2_BSP\Driver\regmap;..\..\..\ELF2_BSP\FreeRTOSv9.0.0\FreeRTOS\Source\include;..\..\..\ELF2_BSP\FreeRTOSv9.0.0\FreeRTOS\Source\portable\Keil\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\elf2_example.sct
  group main
    ./src/: main.c
  group startup
    ../../../ELF2_BSP/Device/ELF2/Source/ARM/: startup_elf2.s
    ../../../ELF2_BSP/Device/ELF2/Source/: system_elf2.c
  group freertos
    ../../../ELF2_BSP/FreeRTOSv9.0.0/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ELF2_BSP/FreeRTOSv9.0.0/FreeRTOS/Source/portable/Keil/ARM_CM3/: port.c
    ../../../ELF2_BSP/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group lib
    ../../../ELF2_BSP/Driver/: ELF2_CM3_Lib.lib
  group log
    ../../../ELF2_BSP/Debug/: log.c debug.c
    ../../../ELF2_BSP/Debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
