# Keil uVision project demo.uvprojx, settings and files
target demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: demo
  AfterMake: fromelf -c -v -a --output=@P.asm Objects\%L
  AfterMake: fromelf --bin --output=@P.bin Objects\%L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\ELF2_BSP;..\..\..\ELF2_BSP\CMSIS\Core\Include;..\..\..\ELF2_BSP\Debug;..\..\..\ELF2_BSP\Debug\RTT;..\..\..\ELF2_BSP\Device\ELF2\Include;..\..\..\ELF2_BSP\Driver;..\..\..\ELF2_BSP\Driver\regmap;..\..\..\ELF2_BSP\Device\ELF2\Source\ARM
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\elf2_example.sct
  link misc: --keep=int_register.o(int_callback_area)
  group main
    ./src/: main.c
  group startup
    ../../../ELF2_BSP/Device/ELF2/Source/: system_elf2.c
    ../../../ELF2_BSP/Device/ELF2/Source/ARM/: startup_elf2.s
  group lib
    ../../../ELF2_BSP/Driver/: ELF2_CM3_Lib.lib int_register.c intc.c
  group log
    ../../../ELF2_BSP/Debug/: debug.c log.c
    ../../../ELF2_BSP/Debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group driver
    ./src/: test_gpio.c test_gpio.h
