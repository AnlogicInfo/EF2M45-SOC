# Keil uVision project Quick_Start.uvprojx, settings and files
target Quick_Start (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Quick_Start
  AfterMake: fromelf -c -v -a --output=@P.asm Objects\%L
  AfterMake: fromelf --bin --output=@P.bin Objects\%L
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\ELF2_BSP;..\..\..\ELF2_BSP\CMSIS\Core\Include;..\..\..\ELF2_BSP\Debug;..\..\..\ELF2_BSP\Debug\RTT;..\..\..\ELF2_BSP\Driver;..\..\..\ELF2_BSP\Driver\regmap;..\..\..\ELF2_BSP\Device\ELF2\Include;..\..\..\ELF2_BSP\Device\ELF2\Source\ARM;..\..\..\ELF2_BSP\FatFs11a\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\elf2_example.sct
  link misc: --keep=int_register.o(int_callback_area)
  group main
    ./src/: main.c test_gpio.c test_gpio.h
    ../../../ELF2_BSP/Driver/: int_register.c intc.c
  group startup
    ../../../ELF2_BSP/Device/ELF2/Source/ARM/: startup_elf2.s
    ../../../ELF2_BSP/Device/ELF2/Source/: system_elf2.c
  group lib
    ../../../ELF2_BSP/Driver/: ELF2_CM3_Lib.lib
  group log
    ../../../ELF2_BSP/Debug/: log.c debug.c
    ../../../ELF2_BSP/Debug/RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
  group driver
    ./src/: spi_driver_sd.c
  group fatfs
    ../../../ELF2_BSP/FatFs11a/src/: diskio.c ff.c
    ../../../ELF2_BSP/FatFs11a/src/option/: ccsbcs.c
